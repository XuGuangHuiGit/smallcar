# Keil uVision project STM32F103demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=SPI.bin  ./Output/STM32F103demo.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\FWLIB\inc;.\User;.\Project;.\Libraries\CMSIS;.\freertos\Source\include;.\freertos\Source;.\freertos\Source\portable\RVDS\ARM_CM3;.\freertos
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group Project
    ./Project/: USART.c can.c rcc.c TIM.c cmd.c cmd_func.c lcd.c gpio.c outputdata.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ./Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group freertos
    ./freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ./freertos/Source/portable/MemMang/: heap_2.c
    ./freertos/Source/: queue.c list.c tasks.c
